# Keil uVision project STM32G474.uvprojx, settings and files
target AEiSy_Px (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EBSy_Px
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\System;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./System/: startup_stm32g474xx.s
    ./: main.c
  group System
    ./System/: stm32g4xx.h STM32G4xx_REG_ASM.inc stm32g474xx.h system_stm32g4xx.c
  group Utilities
    ./: delay.h delay.s event.c event.h delayus.s
  group Hardware
    ./: led.h led.c lcd.c lcd.h gpio.h us_sensor.h us_sensor.c compass.c compass.h pwm.c pwm.h odometer.c odometer.h
  group Application
    ./: isr.c isr.h eventhandler.c eventhandler.h motor.c motor.h autodrive.c autodrive.h
